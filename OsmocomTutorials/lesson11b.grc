options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '6'
    high_cutoff_freq: 200e3
    low_cutoff_freq: 100e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pentoo/Desktop/gnuRadioTutorials/5_imparmentsOfWireless/test.txt
    repeat: 'True'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 27e6
    gain0: '0'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=2e5f3f1f
    bb_gain0: '24'
    freq0: 26e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate*4
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '24'
    freq0: 26e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate*4
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*4
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [band_pass_filter_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
